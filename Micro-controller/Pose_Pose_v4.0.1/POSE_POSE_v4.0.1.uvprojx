# Keil uVision project POSE_POSE_v4.0.1.uvprojx, settings and files
target ANO_Settler (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ANO_Settler +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,__CC_ARM,ARM_MATH_CM3
  c include: .\ANO_Settler;.\Driver;.\STM32_LIB\CMSIS;.\STM32_LIB\LIB\inc;.\USB_hid;.\USB_library;.\Driver\VL53L0X\core\inc;.\Driver\VL53L0X\core\src;.\Driver\VL53L0X\demo;.\Driver\VL53L0X\platform\inc;.\Driver\VL53L0X\platform\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ANO_Settler
    ./ANO_Settler/: include.h main.c ANO_Config.h loop.c loop.h ANO_Init.c ANO_Init.h ANO_Data.c ANO_Data.h ANO_PID.c ANO_PID.h filter.c filter.h ANO_Param.c ANO_Param.h ANO_Data_Transfer.c ANO_Data_Transfer.h imu.c imu.h
  group Driver
    ./Driver/: ANO_Drv_LED.c ANO_Drv_LED.h ANO_Drv_SPI.c ANO_Drv_SPI.h ANO_Drv_Uart.c ANO_Drv_Uart.h ANO_Drv_Uart3.c ANO_Drv_Uart3.h stm32f10x_it.c stm32f10x_it.h bsp_SysTick.c bsp_SysTick.h i2c_soft.c i2c_soft.h mymath.c mymath.h time.c time.h ANO_Drv_Flash.c ANO_Drv_Flash.h POSE_Drv_MPU9250.c POSE_Drv_MPU9250.h ANO_Drv_MPU6050.c ANO_Drv_MPU6050.h DL_LN3X.c DL_LN3X.h vl53l0x.c vl53l0x.h ms5611.c ms5611.h
  group STM32_LIB
    ./STM32_LIB/CMSIS/: stm32f10x.h core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s arm_common_tables.c arm_cos_f32.c arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_sin_f32.c arm_cortexM3b_math.lib arm_mat_mult_f32.c
    ./STM32_LIB/LIB/inc/: stm32f10x_conf.h
    ./STM32_LIB/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group DOC
    ./doc/: record.txt txt.txt
  group VL15310x
    ./Driver/VL53L0X/core/inc/: vl53l0x_api.h vl53l0x_api_calibration.h vl53l0x_api_core.h vl53l0x_api_ranging.h vl53l0x_api_strings.h vl53l0x_def.h vl53l0x_device.h vl53l0x_interrupt_threshold_settings.h vl53l0x_tuning.h vl53l0x_types.h
    ./Driver/VL53L0X/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ./Driver/VL53L0X/platform/inc/: vl53l0x_platform.h vl53l0x_platform_log.h
    ./Driver/VL53L0X/platform/src/: vl53l0x_platform.c
software components: CMSIS:CORE 4.3.0
